Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_4/temp/exporttempdir_1096_510_WM013/format_0/TA 33(400).ifc
Time: 2022-08-19T09:06:50
Made in: PARTsolutions

# IfcProject, TA 33
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 33(400)
In: BUILDING
Description: TA 33
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 149224
ePset_PARTsolutions - NB: TA 33(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 33; CATALOG: Baustahlgewebe GmbH; TYP: TA 33; ARTNR: 149224; LODLEVEL: 400; MA: Rebar mesh; G: 2.025; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 245; LVL: 400; LGES: 645; BGES: 328; BI: 294
