Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_4/temp/exporttempdir_1096_428_KjxfK/format_0/TA 14(400).ifc
Time: 2022-08-19T09:00:14
Made in: PARTsolutions

# IfcProject, TA 14
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 14(400)
In: BUILDING
Description: TA 14
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 151312
ePset_PARTsolutions - NB: TA 14(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 14; CATALOG: Baustahlgewebe GmbH; TYP: TA 14; ARTNR: 151312; LODLEVEL: 400; MA: Rebar mesh; G: 1.373; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 115; LVL: 400; LGES: 515; BGES: 138; BI: 107
