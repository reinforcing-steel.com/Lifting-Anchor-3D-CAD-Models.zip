Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_2/temp/exporttempdir_3916_185_LDXVf/format_0/TA 35(400).ifc
Time: 2022-08-19T09:07:29
Made in: PARTsolutions

# IfcProject, TA 35
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 35(400)
In: BUILDING
Description: TA 35
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 149226
ePset_PARTsolutions - NB: TA 35(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 35; CATALOG: Baustahlgewebe GmbH; TYP: TA 35; ARTNR: 149226; LODLEVEL: 400; MA: Rebar mesh; G: 2.085; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 265; LVL: 400; LGES: 665; BGES: 348; BI: 312
