Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_2/temp/exporttempdir_3916_180_IpKxe/format_0/TA 29(400).ifc
Time: 2022-08-19T09:04:56
Made in: PARTsolutions

# IfcProject, TA 29
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 29(400)
In: BUILDING
Description: TA 29
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 149220
ePset_PARTsolutions - NB: TA 29(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 29; CATALOG: Baustahlgewebe GmbH; TYP: TA 29; ARTNR: 149220; LODLEVEL: 400; MA: Rebar mesh; G: 1.867; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 205; LVL: 400; LGES: 605; BGES: 288; BI: 255
