Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_2/temp/exporttempdir_3916_158_M2zOa/format_0/TA 19(400).ifc
Time: 2022-08-19T09:02:54
Made in: PARTsolutions

# IfcProject, TA 19
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 19(400)
In: BUILDING
Description: TA 19
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 149211
ePset_PARTsolutions - NB: TA 19(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 19; CATALOG: Baustahlgewebe GmbH; TYP: TA 19; ARTNR: 149211; LODLEVEL: 400; MA: Rebar mesh; G: 1.504; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 110; LVL: 400; LGES: 510; BGES: 188; BI: 151
