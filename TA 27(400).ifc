Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_4/temp/exporttempdir_1096_475_Bx9Q3/format_0/TA 27(400).ifc
Time: 2022-08-19T09:04:31
Made in: PARTsolutions

# IfcProject, TA 27
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 27(400)
In: BUILDING
Description: TA 27
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 149218
ePset_PARTsolutions - NB: TA 27(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 27; CATALOG: Baustahlgewebe GmbH; TYP: TA 27; ARTNR: 149218; LODLEVEL: 400; MA: Rebar mesh; G: 1.795; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 185; LVL: 400; LGES: 585; BGES: 268; BI: 235
