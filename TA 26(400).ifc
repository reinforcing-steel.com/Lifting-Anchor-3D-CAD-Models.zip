Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_2/temp/exporttempdir_3916_179_jKWYf/format_0/TA 26(400).ifc
Time: 2022-08-19T09:04:18
Made in: PARTsolutions

# IfcProject, TA 26
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 26(400)
In: BUILDING
Description: TA 26
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 149156
ePset_PARTsolutions - NB: TA 26(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 26; CATALOG: Baustahlgewebe GmbH; TYP: TA 26; ARTNR: 149156; LODLEVEL: 400; MA: Rebar mesh; G: 1.758; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 180; LVL: 400; LGES: 580; BGES: 258; BI: 225
