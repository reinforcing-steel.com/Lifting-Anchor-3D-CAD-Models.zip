Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_4/temp/exporttempdir_1096_492_O7qnf/format_0/TA 31(400).ifc
Time: 2022-08-19T09:05:36
Made in: PARTsolutions

# IfcProject, TA 31
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 31(400)
In: BUILDING
Description: TA 31
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 149222
ePset_PARTsolutions - NB: TA 31(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 31; CATALOG: Baustahlgewebe GmbH; TYP: TA 31; ARTNR: 149222; LODLEVEL: 400; MA: Rebar mesh; G: 1.951; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 225; LVL: 400; LGES: 625; BGES: 308; BI: 275
