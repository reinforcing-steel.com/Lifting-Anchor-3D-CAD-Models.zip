Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_2/temp/exporttempdir_3916_176_hNTS6/format_0/TA 23(400).ifc
Time: 2022-08-19T09:03:47
Made in: PARTsolutions

# IfcProject, TA 23
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 23(400)
In: BUILDING
Description: TA 23
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 149215
ePset_PARTsolutions - NB: TA 23(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 23; CATALOG: Baustahlgewebe GmbH; TYP: TA 23; ARTNR: 149215; LODLEVEL: 400; MA: Rebar mesh; G: 1.650; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 150; LVL: 400; LGES: 550; BGES: 228; BI: 195
