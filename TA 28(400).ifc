Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_4/temp/exporttempdir_1096_476_8LP55/format_0/TA 28(400).ifc
Time: 2022-08-19T09:04:47
Made in: PARTsolutions

# IfcProject, TA 28
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 28(400)
In: BUILDING
Description: TA 28
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 149219
ePset_PARTsolutions - NB: TA 28(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 28; CATALOG: Baustahlgewebe GmbH; TYP: TA 28; ARTNR: 149219; LODLEVEL: 400; MA: Rebar mesh; G: 1.831; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 195; LVL: 400; LGES: 630; BGES: 278; BI: 245
