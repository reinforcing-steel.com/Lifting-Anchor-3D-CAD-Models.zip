Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_4/temp/exporttempdir_1096_455_3Mqpl/format_0/TA 15(400).ifc
Time: 2022-08-19T09:01:34
Made in: PARTsolutions

# IfcProject, TA 15
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 15(400)
In: BUILDING
Description: TA 15
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 149207
ePset_PARTsolutions - NB: TA 15(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 15; CATALOG: Baustahlgewebe GmbH; TYP: TA 15; ARTNR: 149207; LODLEVEL: 400; MA: Rebar mesh; G: 1.385; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 90; LVL: 400; LGES: 490; BGES: 148; BI: 115
