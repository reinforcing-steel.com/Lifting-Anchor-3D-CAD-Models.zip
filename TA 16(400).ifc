Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_4/temp/exporttempdir_1096_456_asxWM/format_0/TA 16(400).ifc
Time: 2022-08-19T09:01:46
Made in: PARTsolutions

# IfcProject, TA 16
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 16(400)
In: BUILDING
Description: TA 16
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 149208
ePset_PARTsolutions - NB: TA 16(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 16; CATALOG: Baustahlgewebe GmbH; TYP: TA 16; ARTNR: 149208; LODLEVEL: 400; MA: Rebar mesh; G: 1.408; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 100; LVL: 400; LGES: 500; BGES: 158; BI: 125
