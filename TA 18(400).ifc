Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_4/temp/exporttempdir_1096_458_xYQyu/format_0/TA 18(400).ifc
Time: 2022-08-19T09:02:03
Made in: PARTsolutions

# IfcProject, TA 18
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 18(400)
In: BUILDING
Description: TA 18
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 149210
ePset_PARTsolutions - NB: TA 18(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 18; CATALOG: Baustahlgewebe GmbH; TYP: TA 18; ARTNR: 149210; LODLEVEL: 400; MA: Rebar mesh; G: 1.480; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 115; LVL: 400; LGES: 515; BGES: 178; BI: 145
