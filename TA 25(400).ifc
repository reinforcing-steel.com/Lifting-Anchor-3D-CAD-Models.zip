Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_2/temp/exporttempdir_3916_178_caodK/format_0/TA 25(400).ifc
Time: 2022-08-19T09:04:08
Made in: PARTsolutions

# IfcProject, TA 25
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 25(400)
In: BUILDING
Description: TA 25
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 149217
ePset_PARTsolutions - NB: TA 25(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 25; CATALOG: Baustahlgewebe GmbH; TYP: TA 25; ARTNR: 149217; LODLEVEL: 400; MA: Rebar mesh; G: 1.722; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 170; LVL: 400; LGES: 570; BGES: 248; BI: 215
