Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_2/temp/exporttempdir_3916_177_TBA1A/format_0/TA 24(400).ifc
Time: 2022-08-19T09:03:58
Made in: PARTsolutions

# IfcProject, TA 24
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 24(400)
In: BUILDING
Description: TA 24
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 149216
ePset_PARTsolutions - NB: TA 24(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 24; CATALOG: Baustahlgewebe GmbH; TYP: TA 24; ARTNR: 149216; LODLEVEL: 400; MA: Rebar mesh; G: 1.686; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 160; LVL: 400; LGES: 560; BGES: 238; BI: 205
