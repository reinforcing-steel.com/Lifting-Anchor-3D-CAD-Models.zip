Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_4/temp/exporttempdir_1096_457_SZ1Ae/format_0/TA 17(400).ifc
Time: 2022-08-19T09:01:54
Made in: PARTsolutions

# IfcProject, TA 17
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 17(400)
In: BUILDING
Description: TA 17
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 149209
ePset_PARTsolutions - NB: TA 17(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 17; CATALOG: Baustahlgewebe GmbH; TYP: TA 17; ARTNR: 149209; LODLEVEL: 400; MA: Rebar mesh; G: 1.444; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 110; LVL: 400; LGES: 510; BGES: 168; BI: 133
