Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_2/temp/exporttempdir_3916_159_bB5PB/format_0/TA 20(400).ifc
Time: 2022-08-19T09:03:03
Made in: PARTsolutions

# IfcProject, TA 20
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 20(400)
In: BUILDING
Description: TA 20
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 149212
ePset_PARTsolutions - NB: TA 20(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 20; CATALOG: Baustahlgewebe GmbH; TYP: TA 20; ARTNR: 149212; LODLEVEL: 400; MA: Rebar mesh; G: 1.540; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 120; LVL: 400; LGES: 520; BGES: 198; BI: 165
