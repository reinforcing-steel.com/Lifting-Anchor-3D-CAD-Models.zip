Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_2/temp/exporttempdir_3916_160_x2jX4/format_0/TA 21(400).ifc
Time: 2022-08-19T09:03:12
Made in: PARTsolutions

# IfcProject, TA 21
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 21(400)
In: BUILDING
Description: TA 21
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 149213
ePset_PARTsolutions - NB: TA 21(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 21; CATALOG: Baustahlgewebe GmbH; TYP: TA 21; ARTNR: 149213; LODLEVEL: 400; MA: Rebar mesh; G: 1.578; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 135; LVL: 400; LGES: 535; BGES: 208; BI: 175
