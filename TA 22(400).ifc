Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_2/temp/exporttempdir_3916_162_IhJ4c/format_0/TA 22(400).ifc
Time: 2022-08-19T09:03:20
Made in: PARTsolutions

# IfcProject, TA 22
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 22(400)
In: BUILDING
Description: TA 22
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 149214
ePset_PARTsolutions - NB: TA 22(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 22; CATALOG: Baustahlgewebe GmbH; TYP: TA 22; ARTNR: 149214; LODLEVEL: 400; MA: Rebar mesh; G: 1.614; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 140; LVL: 400; LGES: 540; BGES: 218; BI: 183
