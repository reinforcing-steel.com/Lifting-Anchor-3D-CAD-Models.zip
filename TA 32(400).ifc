Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_2/temp/exporttempdir_3916_182_8dLvE/format_0/TA 32(400).ifc
Time: 2022-08-19T09:06:41
Made in: PARTsolutions

# IfcProject, TA 32
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 32(400)
In: BUILDING
Description: TA 32
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 149223
ePset_PARTsolutions - NB: TA 32(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 32; CATALOG: Baustahlgewebe GmbH; TYP: TA 32; ARTNR: 149223; LODLEVEL: 400; MA: Rebar mesh; G: 1.987; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 235; LVL: 400; LGES: 635; BGES: 318; BI: 283
