Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_4/temp/exporttempdir_1096_491_siCa9/format_0/TA 30(400).ifc
Time: 2022-08-19T09:05:24
Made in: PARTsolutions

# IfcProject, TA 30
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 30(400)
In: BUILDING
Description: TA 30
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 149221
ePset_PARTsolutions - NB: TA 30(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 30; CATALOG: Baustahlgewebe GmbH; TYP: TA 30; ARTNR: 149221; LODLEVEL: 400; MA: Rebar mesh; G: 1.903; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 210; LVL: 400; LGES: 610; BGES: 298; BI: 267
