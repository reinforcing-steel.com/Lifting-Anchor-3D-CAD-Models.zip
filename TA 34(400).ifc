Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_2/temp/exporttempdir_3916_184_zOrTl/format_0/TA 34(400).ifc
Time: 2022-08-19T09:07:22
Made in: PARTsolutions

# IfcProject, TA 34
Description: Transportanker für Doppelwand

# IfcDiscreteAccessory, TA 34(400)
In: BUILDING
Description: TA 34
Pset_ManufacturerTypeInformation - Manufacturer: NDW; ArticleNumber: 149225
ePset_PARTsolutions - NB: TA 34(400); NN: TA; NT: Transport anchor for double wall; NBSYN: $TYP.($LODLEVEL.); LINA: TA 34; CATALOG: Baustahlgewebe GmbH; TYP: TA 34; ARTNR: 149225; LODLEVEL: 400; MA: Rebar mesh; G: 2.049; MAT: Wire rod ribbed; LINK: https://www.baustahlgewebe.com/de/produkte/transportanker; L1: 255; LVL: 400; LGES: 655; BGES: 338; BI: 305
